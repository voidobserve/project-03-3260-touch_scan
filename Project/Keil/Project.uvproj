# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Project +hex
  c flags: Optimize=8
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\User\lib;..\..\Hardware
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group LIb
    ../../User/lib/: tk_simplify_algorithm_V1.0.0.LIB
  group Hardware
    ../../Hardware/: uart0.c
  group User
    ../../User/lib/: tk_config.h tk_set.c
    ../../User/: main.c my_config.h send_data.c tk_user.c
